# Keil uVision project IAP.uvprojx, settings and files
target IAP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IAP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HAL;..\HAL\STM32F10x_FWLib\inc;..\Drivers;..\Applications\IAP;..\Applications\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group HAL
    ../HAL/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group HAL\Libs
    ../HAL/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drivers
    ../Drivers/: can.c key.c lcd.c led.c stmflash.c timer.c
  group Applications\SYSTEM
    ../Applications/SYSTEM/: delay.c sys.c usart.c
  group Applications\IAP
    ../Applications/IAP/: iap.c
    ../Applications/: main.c
